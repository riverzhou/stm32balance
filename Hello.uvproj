# Keil uVision project Hello.uvproj, settings and files
target Hello (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Hello +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\DEVICE;.\SYSTEM;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group DEVICE
    ./: startup_stm32f10x_md.s
    ./DEVICE/: system_stm32f10x.c
  group USER
    ./USER/: main.c control.c
  group SYSTEM
    ./SYSTEM/: Retarget.c Serial.c ioi2c.c delay.c exti.c sys.c
  group HARDWARE
    ./HARDWARE/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c motor.c encoder.c
